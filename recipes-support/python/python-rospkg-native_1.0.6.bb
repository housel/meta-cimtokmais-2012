require python-rospkg_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS_${PN} = ""
PR = "r0"
