SECTION = "libs"
require recipes-support/libyaml/libyaml_${PV}.bb
inherit native

PR = "r1"
